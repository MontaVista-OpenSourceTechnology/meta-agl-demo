# Hopefully temporary workaround, patch submitted upstream
DEPENDS += "python3-pip-native"