require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'icu_agldemo.inc', '', d)}
